# Copyright(c) 2020 Fruanhofer IPA

ROS_BUILDTOOL_DEPENDS += " \
    ${PYTHON_PN}-pyyaml-native \
"
